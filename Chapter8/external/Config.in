## Chapter8/package/elehbr/Config.in
```kconfig
config BR2_PACKAGE_ELEHBR
    bool "elehbr"
    help
        Embedded Linux Essentials Handbook Buildroot application.
```
